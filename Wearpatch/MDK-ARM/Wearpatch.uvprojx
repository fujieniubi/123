# Keil uVision project Wearpatch.uvprojx, settings and files
target Wearpatch (6160000::V6.16::ARMCLANG)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.4.0
  cpu: IRAM(0x20000008-0x2002FC07) IROM(0x08000000-0x807FFFF) IRAM2(0x20030000-0x200323FF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Wearpatch +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WB55xx
  c include: ../Core/Inc;../STM32_WPAN/App;../Drivers/STM32WBxx_HAL_Driver/Inc;../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../Utilities/lpm/tiny_lpm;../Middlewares/ST/STM32_WPAN;../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;../Middlewares/ST/STM32_WPAN/utilities;../Middlewares/ST/STM32_WPAN/ble/core;../Middlewares/ST/STM32_WPAN/ble/core/auto;../Middlewares/ST/STM32_WPAN/ble/core/template;../Middlewares/ST/STM32_WPAN/ble/svc/Inc;../Middlewares/ST/STM32_WPAN/ble/svc/Src;../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../Utilities/sequencer;../Middlewares/ST/STM32_WPAN/ble;../Drivers/CMSIS/Include;../MAX5531;../lis2dw12
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000008 size 0x2fc00
  memory RVCT10: RAM 0x20030000 size 0x2400
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c ipcc.c memorymap.c rf.c rtc.c spi.c app_entry.c app_debug.c hw_timerserver.c stm32_lpm_if.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c p2p_server_app.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_ll_adc.c stm32wbxx_hal_rcc.c stm32wbxx_ll_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Middlewares/STM32_WPAN
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: tl_mbox.c hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../Middlewares/ST/STM32_WPAN/ble/svc/Src/: p2p_stm.c svc_ctl.c
  group Utilities
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../Utilities/sequencer/: stm32_seq.c
  group MAX5531
    ../MAX5531/: MAX5531.c
  group lis2dw12
    ../lis2dw12/: lis2dw12_reg.c lis2dw12_read_data_single.c
software components: CMSIS:CORE 5.5.0
